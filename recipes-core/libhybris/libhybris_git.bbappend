FILESEXTRAPATHS_prepend_sawfish := "${THISDIR}/libhybris:"
SRCREV_sawfish = "32c366943b5d9a8f9f5395d15a8804b9b3850035"
SRC_URI_append_sawfish = " file://0001-test_vibrator-Remove-header-check.patch;striplevel=2"
